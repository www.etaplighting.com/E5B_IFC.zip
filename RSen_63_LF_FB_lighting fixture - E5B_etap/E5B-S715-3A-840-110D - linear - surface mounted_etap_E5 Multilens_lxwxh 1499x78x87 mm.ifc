Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: a0334698-a7d6-4b34-85d0-5e3ad416211a, NumberOfSaves: 0]
File name: E5B-S715-3A-840-110D - linear - surface mounted_etap_E5 Multilens_lxwxh 1499x78x87 mm.ifc
Time: 2025-10-02T16:44:43+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.80.30 (ENG) - IFC 23.4.1.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (3)
Pset_AirSideSystemInformation - sets with these values: 2
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 27
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Name | LongName = Pset_AirSideSystemInformation, Name = Identity Data, Name | Elevation (mm) = Constraints, Elevation (mm)
bottom | bottom | -4000
Level 1 | Level 1 | 0
top | top | 4000

# IfcDistributionPort, Port_310785_1
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: RSen_63_LF_FB_lighting fixture - E5B_etap:E5B-S715-3A-840-110D - linear - surface mounted_etap_E5 Multilens_lxwxh 1499x78x87 mm, RSen_63_LF_FB_lighting fixture - E5B_etap:E5B-S715-3A-840-110D - linear - surface mounted_etap_E5 Multilens_lxwxh 1499x78x87 mm:310785
In: bottom
Type - Material: RSen_rgb_236 236 231_T00 RAL9003_etap, RSen_x_rgb 255 128 128 T80 red_gen, <Unnamed>, RSen_rgb_242 242 242 T00 light source_etap
Type - Other - Category: Lighting Fixtures; Family Name: RSen_63_LF_FB_lighting fixture - E5B_etap; RSen_E_c01_description: c01_electrical connector; TB_V_e_c01_plane: 1; TB_V_e_c01_X-coordinate: 0 mm; TB_V_e_c01_Y-coordinate: 0 mm; TB_V_e_c01_Z-coordinate: 0 mm; TBQen_E_c01_system_type: Power - Unbalanced; TBQen_E_c01_yes_no: yes
Type - Model Properties - TB_I_dimmable: Yes; TB_I_dimmer: yes; TB_I_ip: 0; TB_I_lamp.type: LED; TB_I_light.distribution: very wide-angle; TB_I_light.sensor: no; TB_I_module: 7-line-mod; TB_I_mounting: surface mounted; TB_I_optics: acrylic (PMMA); TB_I_shape: linear; TB_I_suspension_max: 0 mm; TB_I_suspension_min: 0 mm
Type - Constraints - Default Elevation: 0 mm
Type - Construction - TB_V_component_01_description: base profile; TB_V_component_01_diameter: 0 mm; TB_V_component_01_fillet_from.plane.radius_01: 0 mm; TB_V_component_01_fillet_from.plane.radius_02: 0 mm; TB_V_component_01_fillet_in.plane.radius: 0 mm; TB_V_component_01_height: 53.5 mm; TB_V_component_01_length: 1499 mm; TB_V_component_01_plane: 2; TB_V_component_01_width: 78 mm; TB_V_component_01_X-coordinate: 0 mm; TB_V_component_01_Y-coordinate: 0 mm; TB_V_component_01_Z-coordinate: 0 mm; TB_V_component_02_description: lighting fixture; TB_V_component_02_diameter: 0 mm; TB_V_component_02_fillet_from.plane.radius_01: 0 mm; TB_V_component_02_fillet_from.plane.radius_02: 0 mm; TB_V_component_02_fillet_in.plane.radius: 0 mm; TB_V_component_02_height: 33.5 mm; TB_V_component_02_length: 1499 mm; TB_V_component_02_plane: 2; TB_V_component_02_width: 78 mm; TB_V_component_02_X-coordinate: 0 mm; TB_V_component_02_Y-coordinate: 0 mm; TB_V_component_02_Z-coordinate: -53.5 mm; TB_V_component_03_description: -; TB_V_component_03_diameter: 0 mm; TB_V_component_03_fillet_from.plane.radius_01: 0 mm; TB_V_component_03_fillet_from.plane.radius_02: 0 mm; TB_V_component_03_fillet_in.plane.radius: 0 mm; TB_V_component_03_height: 0 mm; TB_V_component_03_length: 0 mm; TB_V_component_03_plane: 1; TB_V_component_03_width: 0 mm; TB_V_component_03_X-coordinate: 0 mm; TB_V_component_03_Y-coordinate: 0 mm; TB_V_component_03_Z-coordinate: 0 mm; TB_V_configuration_ceiling.mounted: no; TB_V_configuration_wall.mounted: no; TB_V_logo: RSen_00_GM_FB_logo - SH_etap : standard; TB_V_placement_flush.mounted: no; TB_V_placement_flush.mounted_depth: 0 mm; TB_V_placement_parallel.to.wall: no; TB_V_placement_perpendicular.to.wall: no; TB_V_placement_surface.mounted: yes; TB_V_placement_suspended.horizontally: no; TB_V_placement_suspended.vertically: no; TB_V_sog_plane: 2; TB_V_sog_rotation: 0 deg; TB_V_sog_X-coordinate: 0 mm; TB_V_sog_Y-coordinate: 0 mm; TB_V_sog_Z-coordinate: 0 mm; TB_V_suspension: no; TB_V_suspension_baseplate.height: 0 mm; TB_V_suspension_baseplate.length: 0 mm; TB_V_suspension_baseplate.width: 0 mm; TB_V_suspension_diameter: 0 mm; TB_V_suspension_offset: 0 mm; TB_V_suspension_recess.depth: 0 mm; TB_V_suspension_type: GEO_suspension_gen_thorbiq : none_gen; TB_V_suspension_X-coordinate: 0 mm; TB_V_suspension_Y-coordinate: 0 mm; TBQen_C_accessory_LF_02: RSen_63_LF_FB_accessories_gen_thorbiq : none_gen; TBQen_C_accessory_LF_03: RSen_63_LF_FB_accessories_gen_thorbiq : none_gen; TBQen_C_accessory_LF_04: RSen_63_LF_FB_accessories_gen_thorbiq : none_gen; TBQen_C_accessory_LF_05: RSen_63_LF_FB_accessories_gen_thorbiq : none_gen; TBQen_C_SOg_LF_2D: RSen_00_LF_FB_placeholder for SOg_thorbiq : none; TBQen_C_SOg_LF_3D: RSen_63_LF_FB_SOg - E5B_etap_tbq : E5B-S715
Type - Dimensions - RSen_C_diameter: 0 mm; RSen_C_height: 87 mm; RSen_C_length: 1499 mm; RSen_C_width: 78 mm
Type - Electrical - RSen_E_c01_apparent_power: 73 W; RSen_E_c01_consumer_star_switched: no; RSen_E_c01_consumer_triangle_switched: no; RSen_E_c01_current: 0 A; RSen_E_c01_division_engine: no; RSen_E_c01_number_of_poles: 1; RSen_E_c01_voltage: 230 V; TB_V_power_apparent: 0 W; TBQen_E_apparent_load: 73 W; TBQen_E_c01_power: 73 W; TBQen_E_c01_power_factor: 1; TBQen_E_c01_utility: no; TBQen_E_number_of_lamps: 1; TBQen_E_wattage_ballast: 5 W; TBQen_E_wattage_per_lamp: 0 W
Type - Graphics - TB_V_clearance.zone_back: 0 mm; TB_V_clearance.zone_bottom: 0 mm; TB_V_clearance.zone_front: 0 mm; TB_V_clearance.zone_left: 0 mm; TB_V_clearance.zone_right: 0 mm; TB_V_clearance.zone_top: 0 mm; TB_V_symbol_ceiling_type: RSen_63_DI_FB_rectangular lighting fixture - led_gen_witas : rectangular lighting fixture - led_gen; TB_V_symbol_wall_type: RSen_63_DI_FB_lighting fixture - none_gen_witas : none_gen
Type - Identity Data - Assembly Code: 63.10.30; Description: Industrial line luminaire, with industrial driver.; Manufacturer: gen; Model: E5 Multilens; RSen_C_code_article: E5B-S715-3A-840-110D; RSen_C_code_ETIM: Plafond-/wandarmatuur; RSen_C_code_ETIM_URL: http://prod.etim-international.com/Class/Details?classId=EC002892&classVersion=2; RSen_C_code_gtin: -; RSen_C_code_product_class: -; RSen_C_content_creator: © ThorbiQ; RSen_C_content_date_changed: 30/09/2025; RSen_C_content_date_issue: 30/09/2025; RSen_C_content_provider: gen; RSen_C_content_version: 1.0.0; RSen_C_description: Industrial line luminaire, with industrial driver.; RSen_C_model: E5 Multilens; RSen_C_revit_version: 2022; RSen_C_type: individual luminaire; RSen_C_type_comments: luminaire; TB_I_basekeynote: 63.10.30; TBQen_C_IFC_version: 2x3; TBQen_C_license: Creative Commons Attribution NoDerivs (CC-ND); TBQen_C_license_info: https://tldrlegal.com/license/creative-commons-attribution-noderivs-(cc-nd)#summary; Type Name: E5B-S715-3A-840-110D - linear - surface mounted_etap_E5 Multilens_lxwxh 1499x78x87 mm; URL: -
Type - Photometrics - Color Filter: 16777215; Dimming Lamp Color Temperature Shift: <None>; Efficacy: 148.542 s3*lm/kg/m2; Illuminance: 11.8206 lx; Initial Color: 0; Initial Color Temperature: 4000 K; Initial Intensity: 0; Light Loss Factor: 0; Light Source Definition (family): Point+Photometric Web; Luminous Flux: 11000 lm; Luminous Intensity: 109.817 cd; Photometric Web File: C:\ProgramData\Autodesk\ApplicationPlugins\Witas RME_BE_NL Localiser.bundle\IES\E5B-S715-3A-840-110D_LTRevAB.ies; TB_V_field_spot_slope.angle: 0 deg; TB_V_light.source_diameter: 1499 mm; TB_V_light.source_length: 1499 mm; TB_V_light.source_plane: 1; TB_V_light.source_type: RSen_63_LF_FB_light source - rectangular - photometric web_gen_witas : standard_gen; TB_V_light.source_width: 78 mm; TB_V_radius_spot_slope.angle: 90 deg; TB_V_shape_light.source_visible.in.rendering: yes; TB_V_slope.angle: 90 deg; TB_V_symbol.power.balanced_light.source_dimension: 0 mm; Tilt Angle: -90 deg; Total Light Loss Factor: 1; Wattage: 9.2903 W
Type - Materials and Finishes - RSen_C_material: RSen_rgb_236 236 231_T00 RAL9003_etap; TB_V_clearance.zone_material: RSen_x_rgb 255 128 128 T80 red_gen; TB_V_component_01_material: RSen_rgb_236 236 231_T00 RAL9003_etap; TB_V_component_02_material: RSen_rgb_236 236 231_T00 RAL9003_etap
Type - Pset_ManufacturerTypeInformation - Manufacturer: gen
Classification: 63.10.30 (Uniformat); Material: RSen_rgb_242 242 242 T00 light source_etap, RSen_rgb_236 236 231_T00 RAL9003_etap
Pset_DistributionFlowElementCommon - Reference: E5B-S715-3A-840-110D - linear - surface mounted_etap_E5 Multilens_lxwxh 1499x78x87 mm; sets with these values: 2
Other - Family: RSen_63_LF_FB_lighting fixture - E5B_etap; Family and Type: RSen_63_LF_FB_lighting fixture - E5B_etap: E5B-S715-3A-840-110D - linear - surface mounted_etap_E5 Multilens_lxwxh 1499x78x87 mm; Type: E5B-S715-3A-840-110D - linear - surface mounted_etap_E5 Multilens_lxwxh 1499x78x87 mm; Type Id: 309574
Constraints - Elevation from Level: 0 mm; Host: Reference Plane : h_rightleft
Construction - TB_V_suspension_height: 0 mm; TBQen_C_accessory_LF_01: RSen_63_LF_FB_accessories_gen_thorbiq : none_gen; TBQen_C_alignment: Center; TBQen_C_alignment_index: 0; TBQen_C_GOg: no; TBQen_C_SOg: yes
Dimensions - Area: 4.73616 m2; Volume: 0.142414 m3
Electrical - RSen_E_c01_load_class: Lighting
Electrical - Circuiting - Electrical Data: c01_electrical connector 230 V/1-73 VA
Electrical - Lighting - Calculate Coefficient of Utilization: yes
Electrical - Loads - TBQen_E_simultaneity_factor: 1
Graphics - TBQen_C_clearance_zone: no; TBQen_C_logo: no
Identity Data - Mark: 64
Phasing - Phase Created: New Construction
